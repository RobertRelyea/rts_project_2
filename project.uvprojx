# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c misc: --c99 -D__MICROLIB
  c include: ..\..\..\..\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Source Group 1
    ./: main.c pins.txt servo_recipes.c
  group Drivers
    ./: stm32l476xx.h startup_stm32l476xx.s
    ./Drivers/: input_pa1.h input_pa1.c UART.c SysClock.c LED.c pa6_config.c pa6_config.h tim4.c tim4.h LED.h
software components: CMSIS:CORE 4.3.0
